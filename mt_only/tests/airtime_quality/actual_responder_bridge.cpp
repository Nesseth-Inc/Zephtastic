// SPDX-License-Identifier: GPL-3.0-only
// Two actual Services. Peer data is generated by the real responder.
#include "telemetry_query_fixture.h"
#include "observation_adapter.h"
#include "known_channel_fixture.h"
#include <cmath>
#ifdef NDEBUG
#error Acceptance requires enabled assertions
#endif
static std::vector<uint8_t> unhex(const char *p){std::string s=p;assert(s.size()%2==0);std::vector<uint8_t>b;for(size_t i=0;i<s.size();i+=2)b.push_back(uint8_t(std::stoul(s.substr(i,2),nullptr,16)));return b;}
static std::string hex(const uint8_t *p,size_t n){constexpr char h[]="0123456789abcdef";std::string s;for(size_t i=0;i<n;++i){s+=h[p[i]>>4];s+=h[p[i]&15];}return s;}
static void records(const Host &host,const char *name){for(const auto &o:host.out){uint8_t b[512]{};auto out=pb_ostream_from_buffer(b,sizeof(b));assert(pb_encode(&out,meshtastic_FromRadio_fields,&o));std::cout<<name<<" "<<hex(b,out.bytes_written)<<"\n";}}
int main(int argc,char **argv){
 (void)&group;(void)&results;(void)&telemetries;(void)&beginQuery;(void)&goodFrame;
 if(argc!=5)return 64;
 const auto request=unhex(argv[1]);const uint8_t model=uint8_t(std::stoi(argv[2]));
 const bool ble=std::string(argv[3])=="ble";const std::string mode=argv[4];
 const bool primed=mode=="fraction"||mode=="expired"||mode=="backward"||mode=="lost";
 assert(primed||mode=="unknown"||mode=="idle"||mode=="invalid");
 Fixture requester(true,model);Radio peerRadio;mt::test::KnownChannelFixtureClock peerChannelClock;
 mt::Service peer(peerRadio,true,PEER,model==81?127:81,true,false);
 peerChannelClock.bind(peer);
 qualify::Clock clock;
 if(mode!="unknown")qualify::bindObservation(peer,clock);
 mt::Config cfg;cfg.bytes[4]=1;auto node=cfg.node();node.setPublic();cfg.node(node);
 assert(peer.apply(cfg)&&peer.start(false,0)&&peer.armEndpoint(true));peer.measuredUptime(321);
 Host peerHost(peer);mt::companion::CompanionWorkspace workspace;mt::Companion peerClient(peer,peerHost,model==81?127:81,workspace,0);
 if(primed) {
  meshtastic_ToRadio setup{};setup.which_payload_variant=meshtastic_ToRadio_want_config_id_tag;setup.want_config_id=1;
  clock.ms=1;input(peerClient,setup,1);peerHost.out.clear();
  meshtastic_ToRadio message{};message.which_payload_variant=meshtastic_ToRadio_packet_tag;auto &p=message.packet;
  p.to=0xabcdef01;p.id=0x59001234;p.hop_limit=0;p.which_payload_variant=meshtastic_MeshPacket_decoded_tag;
  p.decoded.portnum=meshtastic_PortNum_TEXT_MESSAGE_APP;p.decoded.payload.size=5;memcpy(p.decoded.payload.bytes,"probe",5);
  peerRadio.air=600;clock.ms=100;input(peerClient,message,100);clock.ms=300;peer.poll(300,0);assert(peerRadio.sends==1);
  clock.ms=301;clock.valid=mode!="lost";peerRadio.done=true;peer.poll(301,0);assert(peer.sent==1);
 }
 // Except for deliberate invalid/backward-provider negatives, the observation
 // clock advances with the uint32 scheduler, including the idle hour.
 const uint32_t base=mode=="expired"?3600000:primed?1000:0;
 auto tick=[&](uint32_t wall){clock.ms=mode=="backward"?300:wall;clock.valid=mode!="invalid";return wall;};
 auto &client=ble?requester.bc:requester.c;const auto begin=tick(base+100);
 if(ble)client.packet(request.data(),request.size(),begin,mt::Companion::WorkspaceProof{true});
 else {client.byte(0x94,begin,0,mt::Companion::WorkspaceProof{true});client.byte(0xc3,begin,0,mt::Companion::WorkspaceProof{true});client.byte(uint8_t(request.size()>>8),begin,0,mt::Companion::WorkspaceProof{true});client.byte(uint8_t(request.size()),begin,0,mt::Companion::WorkspaceProof{true});for(auto b:request)client.byte(b,begin,0,mt::Companion::WorkspaceProof{true});}
 requester.s.poll(tick(base+300),0);assert(requester.radio.sends==1);requester.done(tick(base+301));
 const auto &q=requester.radio.frames[0];const unsigned before=peerRadio.sends;
 peer.rx(q.data(),q.size(),3,tick(base+800),700);peer.poll(tick(base+1200),0);assert(peerRadio.sends==int(before+1));
 const auto reply=peerRadio.frames.back();assert(bench::le32(reply.data())==OURS&&bench::le32(reply.data()+4)==PEER);
 peerRadio.done=true;peer.poll(tick(base+1201),0);
 if(mode=="fraction"||mode=="idle"||mode=="expired") {
  float value=-1;assert(qualify::observedPercent(peer,value));
  const double duration=mode=="fraction"?1200:mode=="expired"?600:100;
  assert(std::fabs(double(value)-duration/36000.0)<0.00000003);
 }
 requester.rx(reply,tick(base+1500));requester.clients();requester.rx(reply,tick(base+1600));requester.clients();
 assert(requester.radio.sends==1&&peerRadio.sends==int(before+1));
 records(requester.h,"USB");records(requester.bh,"BLE");
 std::cout<<"COUNTS "<<requester.radio.sends<<" "<<peerRadio.sends<<"\n";
}
